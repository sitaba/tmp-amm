IMAGE_INSTALL:append = " evtest"
